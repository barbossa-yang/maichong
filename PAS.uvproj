# Keil uVision project PAS.uvproj, settings and files
target frozen soil4G (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: frozen soil4G +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c include: .\user;.\driver;.\startcode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startcode
    ./startcode/: STM32F10x.s
  group user
    ./user/: main.c stm32f10x_it.c
  group driver
    ./driver/: textcmd.c ad5245.c
  group fwlib
    C:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB STM32F10xD.LIB
